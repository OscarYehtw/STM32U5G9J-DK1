# IAR project STM32U5G9J-DK1.ewp, settings and files
configuration STM32U5G9J-DK1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5G9NJ ST STM32U5G9NJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U5G9xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/Target/generated; ../TouchGFX/Target; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../Drivers/BSP/STM32U5x9J-DK; ../Drivers/BSP/Components/mx25um51245g; ../Middlewares/ST/touchgfx/framework/include; ../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: STM32U5G9J-DK1.hex
  ILINK.IlinkOutputFile: STM32U5G9J-DK1.out
  ILINK.IlinkIcfFile: stm32u5g9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: STM32U5G9J-DK1.ipcf
  group Application/EWARM
    ./: startup_stm32u5g9xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_freertos.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/Target
    ../TouchGFX/Target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp
  group Application/User/TouchGFX/Target/generated
    ../TouchGFX/Target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp nema_hal.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/aps512xx/: aps512xx.c
    ../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../Drivers/BSP/Components/sitronix/: sitronix.c sitronix_reg.c
  group Drivers/BSP/STM32U5x9J-DK
    ../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery_bus.c stm32u5x9j_discovery_ts.c stm32u5x9j_discovery_hspi.c stm32u5x9j_discovery_ospi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dsi.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_jpeg.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: portasm.s port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m33/IAR8.x/: nemagfx_core_release.a
    ../Middlewares/ST/touchgfx/lib/core/cortex_m33/IAR8.x/: touchgfx_core.a
    ../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m33/IAR8.x/: touchgfx_nema_release.a
