<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U5G9J-DK1.ewp</path>
  </project>
  <batchBuild />
</workspace>
